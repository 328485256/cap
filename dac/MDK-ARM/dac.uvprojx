# Keil uVision project dac.uvprojx, settings and files
target dac (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: dac +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;.\HARDWARE\LCD;..\MDK-ARM;.\HARDWARE\EXTI_Callback;.\HARDWARE\Data_Processing;.\HARDWARE\BMI088;.\HARDWARE\Relay_Rontrol;.\HARDWARE\Voltage_Calibration;.\HARDWARE\usart;.\HARDWARE\Self_Inspection;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ./: delay.c
    ./HARDWARE/EXTI_Callback/: EXTI_Callback.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/Data_Processing/: Data_Processing.c
    ./HARDWARE/Voltage_Calibration/: Voltage_Calibration.c
    ./HARDWARE/LCD/: display.c
    ../Src/: main.c gpio.c adc.c dac.c dma.c fsmc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./HARDWARE/usart/: UartData.c
    ./HARDWARE/Self_Inspection/: Self_Inspection.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group HARDWARE
    ./HARDWARE/Relay_Rontrol/: Relay_Control.c
    ./HARDWARE/LCD/: lcd.c
software components: CMSIS:CORE 4.3.0
